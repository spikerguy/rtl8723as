## Kconfig
```kconfig
    config RTL8723AS
          tristate "Realtek 8723AS SDIO WiFi Support"
          ---help---
          Help message of RTL8723AS
```
